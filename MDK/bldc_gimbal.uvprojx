# Keil uVision project bldc_gimbal.uvprojx, settings and files
target bldc_gimbal (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HK32G003F4P7 HK_MicroChip
  pack: HKMicroChip.HK32G003xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bldc_gimbal
  AfterMake: fromelf.exe --bin -o ".\bin\app.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\BUTTON;..\EEPROM;..\FLASH;..\hwconf;..\Inc;..\Mcu\HK32G003\Inc;..\Mcu\HK32G003\Driver\HK32G003_StdPeriph_Driver\inc;..\Mcu\HK32G003\Driver\CMSIS\HK32G003\Include;..\Mcu\HK32G003\Driver\CMSIS\CM0\Core;..\motor;..\sensor;..\LEDControl;..\drv
  memory RVCT4: ROM 0x8000000 size 0x3e00
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ../Src/: main.c mc_config.c pid_regulator.c
  group startup
    ../Mcu/HK32G003/Startup/: KEIL_Startup_hk32g003.s
  group driver
    ../EEPROM/: EEPROM.c
    ../FLASH/: flash_helper.c
    ../Mcu/HK32G003/Src/: mc_math.c peripherals.c
    ../Mcu/HK32G003/Driver/HK32G003_StdPeriph_Driver/src/: hk32g003_adc.c hk32g003_flash.c hk32g003_gpio.c hk32g003_iwdg.c hk32g003_pwr.c hk32g003_syscfg.c hk32g003_tim.c hk32g003_uart.c hk32g003_rcc.c hk32g003_misc.c
    ../Mcu/HK32G003/Driver/CMSIS/HK32G003/Source/: system_hk32g003.c
    ../motor/: mcpwm_foc.c
    ../sensor/: qmi8658b.c
    ../drv/: filter.c i2c.c
